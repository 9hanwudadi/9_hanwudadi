# Keil uVision project stc8h8k64u.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(24000000)
  output: stc8h8k64u +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: ADC_START=0x40,ADC_FLAG=0x20
  c include: .\App;.\Driver;.\Lib;.\User
  group App
    ./App/: App_System.c APP_RobotMotion.c APP_Command.c APP_Safety.c
  group Driver
    ./Driver/: pca9685.c servo.c bluetooth.c ultrasonic.c battery.c buzzer.c light.c
  group Lib
    ./Lib/: Soft_I2C.c GPIO.c NVIC.c UART.c UART_Isr.c Timer.c Timer_Isr.c Delay.c ADC.c STC8H_PWM.c
  group User
    ./User/: main.c
  group OS
    ./OS/: Conf_tny.A51 RTX51TNY.LIB
